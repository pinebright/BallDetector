# Repository pinebright/BallDetector

## EAGLE design BallDetector6A/BallDetector6A.brd

Parts:
C3, C4, C5, C7, C11, C13, C14, C15, C16, C18, C23, C24, C25, C26: 100n; 1005
C6, C8, C10: 4.7u; 1608
C9, C19, C21, C22: 1u; 1005
C12: 10u; 1005
C17: 22u; 2012
C20: 10n; 1005
CN1: Ball; 53398-04
CN2: USB micro; ZX62-B-5PA
CN3: CN-NXP-JTAG; PIN2X5-SMT1.27
D1, D2: SBD-SOD523; SOD523
FB1: FB1608; 1608
H1, H4: NUT-M2-MA
H2, H3: NUT-M2-MB
LED1, LED2, LED3, LED4, LED5, LED6: VSMG10850; 3010
LED7: LED1608; 1608
P1, P3: LED+; SPRING-72MIL
P2, P4: LED-; SPRING-72MIL
Q1: BSS138; SOT23-3
R1, R7: 10; 1608
R2, R11, R12, R13: 10k; 1005
R3, R4: 22; 1005
R5, R6, R17: 51; 1005
R8, R14: R1005; 1005
R10: 330; 1005
SW1: SKRP
U1, U2: TSL1401CL-RIGHT5
U3: ATSAM4E8CA-A; QFP100-0.5
U5, U6: MCP1754ST-33; SOT23-3
U7: ADR5041; SC70-3
X1: 12MHz; OSC2520

Connections:
!RESET: CN3.10 (!RESET), R14.1, U3.58 (!RST)
+3V3: C5.1, C10.1, C14.1, C15.1, C19.1, C20.1, C25.1, C26.1, CN3.1 (VREF), R2.2, R10.2, R14.2, U3.5 (VDDIN), U3.19 (VDDIO), U3.28 (VDDIO), U3.68 (VDDIO), U3.93 (VDDIO), U5.2 (VO), X1.1 (EN), X1.4 (VDD)
+3V3/2: C3.1, C4.1, C6.1, C22.1, U1.4 (VDD), U2.4 (VDD), U6.2 (VO)
+5V: C9.1, C17.1, C21.1, D1.K, D2.K, P1.1, U5.3 (VI), U6.3 (VI)
ADVREF: C18.1, R10.1, U3.9 (ADVREF), U7.1 (K)
CAM1_AOP: U1.3 (AO), U3.14 (PA19/PWML0/AFE0_AD2)
CAM1_CLK: U1.2 (CLK), U3.11 (PB1/PWMH1/TXD0/AFE0_AD5/RTCOUT1)
CAM1_SI: U1.1 (SI), U3.1 (PD0/GTXCK_GREFCK)
CAM2_AOP: U2.3 (AO), U3.21 (PA21/RXD1/PCK1/AFE1_AD2)
CAM2_CLK: U2.2 (CLK), U3.27 (PA13/MOSI/PWMH2)
CAM2_SI: U2.1 (SI), U3.23 (PD30)
CASE: H1.1, H1.2, H2.1, H2.2, H3.1, H3.2, H4.1, H4.2
CLK12M: R17.2, U3.99 (PB9/XIN)
GND: C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, CN1.2, CN1.S1, CN1.S2, CN2.5 (GND), CN2.S1, CN2.S2, CN2.S3, CN2.S4, CN3.3 (GND), CN3.5 (GND), CN3.9 (GND), Q1.2 (S), R8.1, R11.2, R13.1, SW1.B1, SW1.B2, U1.6 (GND), U1.7 (GND), U2.6 (GND), U2.7 (GND), U3.3 (GND), U3.6 (GND), U3.7 (GND), U3.8 (GND), U3.10 (GND), U3.29 (GND), U3.67 (GND), U5.1 (GND), U6.1 (GND), U7.2 (A), X1.2 (GND)
GND/2: LED3.K, LED6.K, P4.1
HOST_RX: R5.2, U3.46 (PA10/UTXD0/NPCS2)
HOST_TX: R6.2, U3.54 (PA9/URXD0/NPCS1/PWMFI0)
LED1: LED7.A, U3.47 (PD19)
LED_ENABLE: Q1.1 (G), R11.1, U3.42 (PA26/DCD1/TIOA2/MCDA2/PIODC2)
unnamed: LED1.K, LED2.A
unnamed: LED2.K, LED3.A
unnamed: P3.1, R1.2, R7.2
unnamed: LED4.K, LED5.A
unnamed: LED5.K, LED6.A
unnamed: LED4.A, R7.1
unnamed: LED1.A, R1.1
unnamed: P2.1, Q1.3 (D)
unnamed: CN2.2 (D-), R4.1
unnamed: CN2.3 (D+), R3.1
unnamed: C16.1, CN2.1 (VBUS), D1.A, R12.1
unnamed: R17.1, X1.3 (OUT)
unnamed: CN1.1, R5.1
unnamed: CN1.3, R6.1
unnamed: CN1.4, D2.A
unnamed: LED7.K, R8.2
SW1: SW1.A2, U3.26 (PA22/TXD1/NPCS3/AFE1_AD3)
TCK: CN3.4 (TCK/SWCLK), R2.1, U3.63 (PB7/TCK/SWCLK)
TDI: CN3.8 (TDI), U3.74 (PB4/TWD1/PWMH2/TDI)
TDO: CN3.6 (TDO/SWO), U3.77 (PB5/TWCK1/PWML0/TDO/SWO)
TMS: CN3.2 (TMS/SDCIO), U3.57 (PB6/TMS/SWDIO)
USB_D+: R3.2, U3.95 (PB11/DDP)
USB_D-: R4.2, U3.94 (PB10/DDM)
USB_VBUS: R12.2, R13.2, U3.88 (PD4/GCRSDV_GRXDV)
VDDOUT: C7.1, C8.1, C11.1, C23.1, C24.1, FB1.1, U3.4 (VDDOUT), U3.18 (VDDCORE), U3.22 (VDDCORE), U3.86 (VDDCORE)
VDDPLL: C12.1, C13.1, FB1.2, U3.96 (VDDPLL)

Notes on the sheet:
KIKS2014
Gen.6 Ball Detector
FUJII NAOMICHI
Designed by
Date
2013/12/18
ラインセンサー
LEDs
赤外線LED Vishay VSMG10850 LED基板のスプリング Mill-Max 0900-1-15-20-75-14-11-0

Board: 2 copper layers, 42.0 x 50.0 mm, 68 parts (17 on the bottom side), 45 nets.

## Commit log

2014-09-06 最初のコミット
